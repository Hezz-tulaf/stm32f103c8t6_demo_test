# Keil uVision project STM32F103.uvprojx, settings and files
target STMIAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STMIAP +hex
  AfterMake: D:\Program Files (x86)\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin -o  ./Bin/STMIAP.bin ./Objects/STMIAP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\startup;..\CMSIS;..\FWlib\inc;..\FWlib\src;..\User;..\User\timer;..\User\usart;..\User\global;..\User\bsp_ctr;..\User\rccclk;..\User\led;..\User\systick;..\User\common;..\User\flash;..\User\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x6800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../User/: main.c stm32f10x_it.c
    ../User/global/: global.c
    ../User/systick/: systick.c
    ../User/led/: led.c
    ../User/timer/: timer.c
    ../User/usart/: usart.c
    ../User/bsp_ctr/: bsp_ctr.c
    ../User/flash/: bsp_flash.c
    ../User/rccclk/: clkconfig.c
    ../User/common/: common.c
    ../User/IAP/: iap.c
  group fwlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group cmsis
    ../CMSIS/: system_stm32f10x.c
